# Autodesk Inventor assembly: Baugruppe1_112
## iProperties
Created: 2008-12
Part Number: Baugruppe1_112
Document SubType Name: Assembly
Designer: Wolfgang
Author: Wolfgang
